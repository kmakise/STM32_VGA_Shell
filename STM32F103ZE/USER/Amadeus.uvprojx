# Keil uVision project Amadeus.uvprojx, settings and files
target K.Makise (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Amadeus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\VGA;..\SYSTEM\bitmap;..\HARDWARE\BEEP;..\Amadeus\login;..\HARDWARE\ESP8266;..\Amadeus\cmnct;..\Amadeus\graphical;..\Amadeus\keyboard;..\Amadeus\components;..\Amadeus\terminal;..\Amadeus\functionlib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Entrance
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Sys_Amadeus
    ../Amadeus/graphical/: graphical.c
    ../Amadeus/login/: login.c
    ../Amadeus/cmnct/: cmnct.c
    ../Amadeus/keyboard/: keyboard.c
    ../Amadeus/components/: components.c
    ../Amadeus/terminal/: terminal.c
  group Sys_Terminal
    ../Amadeus/terminal/: TerminalMain.c tmnio.c
  group Sys_FunctionLib
    ../Amadeus/functionlib/: libMaster.c mouse.c systool.c
  group Sys_device
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/bitmap/: bitmap.c str_dealing.c
  group Hareware
    ../HARDWARE/LED/: led.c
    ../HARDWARE/VGA/: vga.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ESP8266/: esp8266.c
  group Core_stm32
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_flash.c
